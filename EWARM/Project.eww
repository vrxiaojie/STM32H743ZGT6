<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32H743ZGT6.ewp</path>
  </project>
  <batchBuild />
</workspace>
